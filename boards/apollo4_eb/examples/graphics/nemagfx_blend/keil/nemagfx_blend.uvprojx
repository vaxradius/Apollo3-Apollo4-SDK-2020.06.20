# Keil uVision project nemagfx_blend.uvprojx, settings and files
target nemagfx_blend (ARM-ADS)
  device: AMAPH1KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.5
  cpu: IROM(0x00000000,0x100000) IRAM(0x10000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: nemagfx_blend
  AfterMake: fromelf --bin --output bin\nemagfx_blend.bin bin\nemagfx_blend.axf
  AfterMake: fromelf -cedrst --output bin\nemagfx_blend.txt bin\nemagfx_blend.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: PLATFORM=apollo4_nemagfx USE_TSI_MALLOC BAREMETAL LD_LIBRARY_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK/lib AM_PACKAGE_BGA AM_PART_APOLLO4 ENABLE_SPI4 NEMAGFX_SDK_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK keil
  c include: ../../../../../../mcu/apollo4/hal;../../../../../../third_party/ThinkSi/config/apollo4_nemagfx;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/NemaGFX;../../../../../../third_party/ThinkSi/NemaGFX_SDK/common/mem;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/common;../src;../../../../../../CMSIS/AmbiqMicro/Include;../../../../../../mcu/apollo4;../../../../bsp;../../../../../../third_party/ThinkSi/NemaGFX_SDK/NemaDC;../../../../../../third_party/ThinkSi/NemaGFX_SDK/NemaGFX;../../../../../../CMSIS/ARM/Include;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/NemaDC;../../../../../../utils;../../../../../..;../../../../../../devices
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo4/hal/mcu/keil/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data)
  group ThinkSi_apollo4_nemagfx
    ../../../../../../third_party/ThinkSi/config/apollo4_nemagfx/: nema_dc_hal.c nema_event.c nema_hal.c nema_utils.c
  group src
    ../src/: am_resources.c main.c nemagfx_blend.c
  group utils
    ../../../../../../utils/: am_util_delay.c am_util_stdio.c
  group devices
    ../../../../../../devices/: am_devices_nemadc_rm67162.c
  group keil
    ../keil/: startup_keil.s
  group lib
    ../../../../bsp/keil/bin/: libam_bsp.lib
    ../../../../../../mcu/apollo4/hal/mcu/keil/bin/: libam_hal.lib
    ../../../../../../third_party/ThinkSi/config/apollo4_nemagfx/keil/bin/: lib_nema_apollo4_nemagfx.lib
