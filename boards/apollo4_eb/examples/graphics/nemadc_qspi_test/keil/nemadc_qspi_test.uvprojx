# Keil uVision project nemadc_qspi_test.uvprojx, settings and files
target nemadc_qspi_test (ARM-ADS)
  device: AMAPH1KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.5
  cpu: IROM(0x00000000,0x100000) IRAM(0x10000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: nemadc_qspi_test
  AfterMake: fromelf --bin --output bin\nemadc_qspi_test.bin bin\nemadc_qspi_test.axf
  AfterMake: fromelf -cedrst --output bin\nemadc_qspi_test.txt bin\nemadc_qspi_test.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AM_PACKAGE_BGA LD_LIBRARY_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK/lib PLATFORM=apollo4_nemagfx USE_TSI_MALLOC AM_PART_APOLLO4 ENABLE_QSPI NEMAGFX_SDK_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK BAREMETAL keil
  c include: ../../../../../../third_party/ThinkSi/NemaGFX_SDK/NemaDC;../../../../../../third_party/ThinkSi/NemaGFX_SDK/common/mem;../../../../../../mcu/apollo4/hal;../../../../../..;../../../../../../devices;../../../../../../third_party/ThinkSi/config/apollo4_nemagfx;../../../../../../third_party/ThinkSi/NemaGFX_SDK/NemaGFX;../src;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/common;../../../../../../utils;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/NemaDC;../../../../../../CMSIS/ARM/Include;../../../../../../mcu/apollo4;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/NemaGFX;../../../../../../CMSIS/AmbiqMicro/Include;../../../../bsp
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo4/hal/mcu/keil/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data)
  group ThinkSi_apollo4_nemagfx
    ../../../../../../third_party/ThinkSi/config/apollo4_nemagfx/: nema_dc_hal.c nema_event.c nema_hal.c nema_utils.c
  group src
    ../src/: am_resources.c main.c nemadc_qspi_test.c
  group utils
    ../../../../../../utils/: am_util_delay.c am_util_stdio.c
  group devices
    ../../../../../../devices/: am_devices_nemadc_rm67162.c
  group keil
    ../keil/: startup_keil.s
  group lib
    ../../../../bsp/keil/bin/: libam_bsp.lib
    ../../../../../../mcu/apollo4/hal/mcu/keil/bin/: libam_hal.lib
    ../../../../../../third_party/ThinkSi/config/apollo4_nemagfx/keil/bin/: lib_nema_apollo4_nemagfx.lib
