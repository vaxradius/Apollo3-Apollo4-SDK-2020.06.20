# Keil uVision project nemagfx_watchface.uvprojx, settings and files
target nemagfx_watchface (ARM-ADS)
  device: AMAPH1KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.5
  cpu: IROM(0x00000000,0x100000) IRAM(0x10000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: nemagfx_watchface
  AfterMake: fromelf --bin --output bin\nemagfx_watchface.bin bin\nemagfx_watchface.axf
  AfterMake: fromelf -cedrst --output bin\nemagfx_watchface.txt bin\nemagfx_watchface.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AM_PACKAGE_BGA USE_TSI_MALLOC LD_LIBRARY_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK/lib NEMAGFX_SDK_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK BAREMETAL ENABLE_SPI4 AM_PART_APOLLO4 AM_FREERTOS PLATFORM=apollo4_nemagfx keil
  c include: ../../../../../../third_party/ThinkSi/NemaGFX_SDK/common/mem;../../../../../../mcu/apollo4/hal;../../../../../../third_party/FreeRTOSv10.1.1/Source/include;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/NemaGFX;../../../../../../CMSIS/AmbiqMicro/Include;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/NemaDC;../../../../bsp;../../../../../../third_party/ThinkSi/NemaGFX_SDK/NemaGFX;../../../../../../third_party/ThinkSi/NemaGFX_SDK/NemaDC;../../../../../../third_party/ThinkSi/config/apollo4_nemagfx;../../../../../../utils;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/common;../../../../../../devices;../../../../../../third_party/FreeRTOSv10.1.1/Source/portable/Keil/AMapollo2;../src;../../../../../..;../../../../../../mcu/apollo4;../../../../../../CMSIS/ARM/Include;../src/generated
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo4/hal/mcu/keil/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data)
  group FreeRTOSv10.1.1_AMapollo2
    ../../../../../../third_party/FreeRTOSv10.1.1/Source/portable/Keil/AMapollo2/: port.c
  group ThinkSi_apollo4_nemagfx
    ../../../../../../third_party/ThinkSi/config/apollo4_nemagfx/: nema_dc_hal.c nema_event.c nema_hal.c nema_utils.c
  group generated
    ../src/generated/: main.c watch.c
  group src
    ../src/: am_resources.c gui_task.c nemagfx_watchface.c rtos.c
  group FreeRTOSv10.1.1_Source
    ../../../../../../third_party/FreeRTOSv10.1.1/Source/: event_groups.c list.c queue.c tasks.c timers.c
  group utils
    ../../../../../../utils/: am_util_delay.c am_util_stdio.c
  group devices
    ../../../../../../devices/: am_devices_nemadc_rm67162.c
  group FreeRTOSv10.1.1_MemMang
    ../../../../../../third_party/FreeRTOSv10.1.1/Source/portable/MemMang/: heap_2.c
  group keil
    ../keil/: startup_keil.s
  group lib
    ../../../../bsp/keil/bin/: libam_bsp.lib
    ../../../../../../third_party/ThinkSi/config/apollo4_nemagfx/keil/bin/: lib_nema_apollo4_nemagfx.lib
    ../../../../../../mcu/apollo4/hal/mcu/keil/bin/: libam_hal.lib
