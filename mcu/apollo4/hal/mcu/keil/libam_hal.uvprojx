# Keil uVision project libam_hal.uvprojx, settings and files
target libam_hal (ARM-ADS)
  device: AMAPH1KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.5
  cpu: IROM(0x00000000,0x100000) IRAM(0x10000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: libam_hal (library)
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AM_PART_APOLLO4 AM_ASSERT_INVALID_THRESHOLD=0 AM_DEBUG_ASSERT keil
  c include: ../../../../../CMSIS/ARM/Include;../../../../../utils;../../../../../mcu/apollo4;../../../../../CMSIS/AmbiqMicro/Include;../../../../../mcu/apollo4/hal
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  group mcu
    ../../../../../mcu/apollo4/hal/mcu/: am_hal_bootrom_helper.c am_hal_cachectrl.c am_hal_clkgen.c am_hal_cmdq.c am_hal_dsi.c am_hal_fault.c am_hal_interrupt.c am_hal_iom.c am_hal_ios.c am_hal_itm.c am_hal_mcuctrl.c am_hal_mram.c am_hal_mspi.c am_hal_reset.c am_hal_rtc.c am_hal_sysctrl.c am_hal_systick.c am_hal_tpiu.c am_hal_uart.c am_hal_utils.c
  group hal
    ../../../../../mcu/apollo4/hal/: am_hal_access.c am_hal_adc.c am_hal_global.c am_hal_gpio.c am_hal_pdm.c am_hal_pin.c am_hal_pwrctrl.c am_hal_queue.c am_hal_security.c am_hal_stimer.c am_hal_timer.c am_hal_usb.c am_hal_wdt.c
